# Keil uVision project STM32F103_CAN.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103_CAN
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\User\Headers;.\CMSIS\Headers
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ./CMSIS/Headers/: core_cm3.h stm32f10x.h system_stm32f10x.h
    ./CMSIS/Sources/: core_cm3.c system_stm32f10x.c
  group Headers
    ./User/Headers/: can.h gpio.h tims.h
  group Users
    ./User/Source/: main.c can.c gpio.c tims.c stm32_its.c
  group Start-up
    ./Startup/: startup_stm32f10x_md.s
