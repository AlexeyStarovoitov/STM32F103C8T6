# Keil uVision project STM32F103 FREERTOS 1.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103 FREERTOS 1
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\CMSIS\Headers;.\User\Headers;.\FreeRTOS\Header
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ./CMSIS/Headers/: core_cm3.h stm32f10x.h system_stm32f10x.h
    ./CMSIS/Sources/: core_cm3.c system_stm32f10x.c
  group Start-up
    ./Startup/: startup_stm32f10x_md.s
  group Headers
    ./User/Headers/: gpio.h spi.h tims.h uart.h free_rtos_tasks.h
  group Sources
    ./User/Sources/: gpio.c main.c spi.c stm32_it.c tims.c uart.c free_rtos_tasks.c
  group FreeRTOS Headers
    ./FreeRTOS/Header/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h FreeRTOSConfig.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h portmacro.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h task.h timers.h
  group FreeRTOS Sources
    ./FreeRTOS/Source/: croutine.c event_groups.c heap_1.c list.c port.c queue.c tasks.c timers.c
