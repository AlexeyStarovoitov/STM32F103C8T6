# Keil uVision project STM32F103 ENC28J60 MQTT TCP.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103 ENC28J60
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\CMSIS\Headers;.\User\Headers;.\libs\MQTT-C\include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ./CMSIS/Headers/: core_cm3.h stm32f10x.h system_stm32f10x.h
    ./CMSIS/Sources/: core_cm3.c system_stm32f10x.c
  group Startup
    ./Startup/: startup_stm32f10x_md.s
  group Header
    ./User/Headers/: gpio.h spi.h enc28j60.h uart.h net.h tims.h
  group User
    ./User/Sources/: main.c spi.c enc28j60.c uart.c stm32_it.c gpio.c net.c tims.c
  group mqtt
    ./libs/MQTT-C/include/: mqtt.h mqtt_pal.h
    ./libs/MQTT-C/src/: mqtt.c mqtt_pal.c
